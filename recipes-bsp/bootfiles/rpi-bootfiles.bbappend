# Ensure this bbappend is applied to Raspberry Pi 5
COMPATIBLE_MACHINE = "^rpi$|^raspberrypi5$"
